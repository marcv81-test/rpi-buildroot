## buildroot/package/rpi-gpio-int/Config.in
```kconfig
config BR2_PACKAGE_RPI_GPIO_INT
	bool "rpi-gpio-int"
	help
	  Raspberry Pi interrupt-based GPIO data acquisition module.
```
